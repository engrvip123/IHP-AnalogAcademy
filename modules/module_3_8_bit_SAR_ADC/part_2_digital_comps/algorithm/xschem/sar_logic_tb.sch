v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 1580 -860 2380 -470 {flags=graph
y1=0
y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.0002
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0



color=4
node=clk}
B 2 2390 -1260 3190 -870 {flags=graph
y1=0
y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.0002
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0



color="4 5 17 7 8 12 18 20"
node="bn0
bn1
bn2
bn3
bn4
bn5
bn6
bn7"}
B 2 2390 -1670 3190 -1280 {flags=graph
y1=0
y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.0002
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0



color="7 6 4 12 13 10 17"
node="d0
d1
d3
d4
d5
d6
d7"}
B 2 1580 -1260 2380 -870 {flags=graph
y1=0
y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.0002
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0



color=4
node=en}
B 2 1580 -1670 2380 -1280 {flags=graph
y1=0
y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.0002
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0



color="7 8"
node="op
om"}
B 2 2390 -860 3190 -470 {flags=graph
y1=0
y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.0002
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0



color="4 5 18 8 13 10 5 7"
node="b0
b1
b2
b3
b4
b5
b6
b7"}
B 2 760 -1670 1560 -1280 {flags=graph
y1=0
y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=0
x2=0.0002
divx=5
subdivx=1


dataset=-1
unitx=1
logx=0
logy=0



color=4
node=rst}
T {Analog} 960 -1020 0 0 0.4 0.4 {}
T {Digital} 770 -1010 0 0 0.4 0.4 {}
N 670 -680 730 -680 {
lab=#net1}
N 340 -1070 340 -1060 {lab=Op}
N 340 -1000 340 -990 {lab=GND}
N 340 -850 340 -840 {lab=Om}
N 340 -780 340 -770 {lab=GND}
N 340 -960 340 -950 {lab=En}
N 340 -890 340 -880 {lab=GND}
N 340 -520 340 -510 {lab=GND}
N 340 -600 340 -580 {lab=rst}
N 670 -740 730 -740 {lab=#net2}
N 670 -760 730 -760 {lab=#net3}
N 670 -720 730 -720 {lab=#net4}
N 590 -680 610 -680 {lab=rst}
N 590 -700 610 -700 {lab=Om}
N 590 -720 610 -720 {lab=En}
N 590 -740 610 -740 {lab=Op}
N 590 -760 610 -760 {lab=clk}
N 670 -700 730 -700 {
lab=#net5}
N 610 -570 610 -540 {lab=clk_reserve}
N 610 -480 610 -470 {lab=GND}
N 1000 -930 1200 -930 {
lab=B5}
N 1000 -910 1200 -910 {lab=B4}
N 1000 -890 1200 -890 {lab=B3}
N 1000 -870 1200 -870 {lab=B2}
N 1000 -850 1200 -850 {lab=B1}
N 1000 -830 1200 -830 {lab=B0}
N 1000 -810 1200 -810 {lab=BN7}
N 1000 -790 1200 -790 {lab=BN6}
N 1000 -770 1200 -770 {lab=BN5}
N 890 -930 940 -930 {lab=#net6}
N 890 -910 940 -910 {lab=#net7}
N 890 -890 940 -890 {lab=#net8}
N 890 -870 940 -870 {lab=#net9}
N 890 -850 940 -850 {lab=#net10}
N 890 -830 940 -830 {lab=#net11}
N 890 -810 940 -810 {lab=#net12}
N 890 -790 940 -790 {lab=#net13}
N 890 -770 940 -770 {lab=#net14}
N 1000 -750 1200 -750 {lab=BN4}
N 1000 -730 1200 -730 {lab=BN3}
N 890 -750 940 -750 {lab=#net15}
N 890 -730 940 -730 {lab=#net16}
N 1000 -710 1200 -710 {lab=BN2}
N 1000 -690 1200 -690 {lab=BN1}
N 890 -710 940 -710 {lab=#net17}
N 890 -690 940 -690 {lab=#net18}
N 1000 -670 1200 -670 {lab=BN0}
N 1000 -650 1200 -650 {lab=D7}
N 890 -670 940 -670 {lab=#net19}
N 890 -650 940 -650 {lab=#net20}
N 1000 -630 1200 -630 {lab=D6}
N 1000 -610 1200 -610 {lab=D5}
N 890 -630 940 -630 {lab=#net21}
N 890 -610 940 -610 {lab=#net22}
N 1000 -590 1200 -590 {lab=D4}
N 1000 -570 1200 -570 {lab=D3}
N 890 -590 940 -590 {lab=#net23}
N 890 -570 940 -570 {lab=#net24}
N 1000 -550 1200 -550 {lab=D2}
N 1000 -530 1200 -530 {lab=D1}
N 890 -550 940 -550 {lab=#net25}
N 890 -530 940 -530 {lab=#net26}
N 1000 -510 1200 -510 {lab=D0}
N 890 -510 940 -510 {lab=#net27}
N 340 -720 340 -710 {lab=clk}
N 340 -650 340 -640 {lab=GND}
C {devices/code_shown.sym} 620 -1130 0 0 {name=NGSPICE only_toplevel=true 
value="
.param temp=27
.control
save all 
tran 1u 200u
write sar_logic.raw
.endc
"}
C {devices/title.sym} 270 -300 0 0 {name=l5 author="Copyright 2024 IHP PDK Authors"}
C {adc_bridge1.sym} 640 -700 0 0 {name=A4
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.2
in_high=0.8
}
C {devices/launcher.sym} 887.5 -440 0 0 {name=h1
descr="load waves Ctrl + left click" 
tclcommand="xschem raw_read $netlist_dir/sar_logic.raw tran"
}
C {adc_bridge1.sym} 640 -680 0 0 {name=A3
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.2 
in_high=0.8
}
C {sar_logic.sym} 810 -720 0 0 {name=adut
dut=dut
d_cosim_model= d_cosim
model=./sar_logic.so}
C {dac_bridge1.sym} 970 -930 0 0 {name=A5
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {dac_bridge1.sym} 970 -910 0 0 {name=A1
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {adc_bridge1.sym} 640 -760 0 0 {name=A6
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.2
in_high=0.8
}
C {adc_bridge1.sym} 640 -740 0 0 {name=A7
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.2
in_high=0.8
}
C {adc_bridge1.sym} 640 -720 0 0 {name=A8
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.2
in_high=0.8
}
C {dac_bridge1.sym} 970 -890 0 0 {name=A9
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {dac_bridge1.sym} 970 -870 0 0 {name=A10
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {dac_bridge1.sym} 970 -850 0 0 {name=A11
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {devices/vsource.sym} 340 -920 0 0 {name=V3 value="dc 0 ac 0 PULSE(1.2 0 0 1n 1n 30u 1m)"}
C {devices/gnd.sym} 340 -990 0 0 {name=l2 lab=GND}
C {devices/lab_pin.sym} 340 -1070 2 0 {name=p5 sig_type=std_logic lab=Op}
C {devices/gnd.sym} 340 -770 0 0 {name=l7 lab=GND}
C {devices/lab_pin.sym} 340 -850 2 0 {name=p8 sig_type=std_logic lab=Om}
C {devices/lab_pin.sym} 340 -960 2 0 {name=p9 sig_type=std_logic lab=En}
C {devices/gnd.sym} 340 -880 0 0 {name=l8 lab=GND}
C {devices/lab_pin.sym} 340 -600 2 0 {name=p11 sig_type=std_logic lab=rst}
C {devices/gnd.sym} 340 -510 0 0 {name=l10 lab=GND}
C {devices/lab_pin.sym} 1200 -930 2 0 {name=p6 sig_type=std_logic lab=B5}
C {devices/lab_pin.sym} 1200 -870 2 0 {name=p7 sig_type=std_logic lab=B2}
C {devices/lab_pin.sym} 1200 -890 2 0 {name=p15 sig_type=std_logic lab=B3}
C {devices/lab_pin.sym} 1200 -910 2 0 {name=p16 sig_type=std_logic lab=B4}
C {devices/vsource.sym} 340 -1030 0 0 {name=V6 value="dc 0 ac 0 PULSE(1.2 0 100u 1n 1n 500u 1m)"}
C {devices/vsource.sym} 340 -550 0 0 {name=V2 value="dc 0 ac 0 PULSE(0 1.2 100u 1n 1n 10u 1m)"}
C {devices/vsource.sym} 610 -510 0 0 {name=V1 value="dc 0 ac 0 pulse(0 1 0 1n 1n 5n 10n)"}
C {devices/gnd.sym} 610 -470 0 0 {name=l3 lab=GND}
C {devices/lab_pin.sym} 610 -570 2 0 {name=p17 sig_type=std_logic lab=clk_reserve}
C {devices/lab_pin.sym} 590 -680 2 1 {name=p2 sig_type=std_logic lab=rst}
C {devices/lab_pin.sym} 590 -760 2 1 {name=p12 sig_type=std_logic lab=clk}
C {devices/vsource.sym} 340 -810 0 0 {name=V5 value="dc 0 ac 0 PULSE(0 1.2 100u 1n 1n 500u 1m)"}
C {devices/lab_pin.sym} 590 -740 2 1 {name=p3 sig_type=std_logic lab=Op}
C {devices/lab_pin.sym} 590 -720 2 1 {name=p13 sig_type=std_logic lab=En}
C {devices/lab_pin.sym} 590 -700 2 1 {name=p14 sig_type=std_logic lab=Om}
C {dac_bridge1.sym} 970 -830 0 0 {name=A12
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {devices/lab_pin.sym} 1200 -850 2 0 {name=p18 sig_type=std_logic lab=B1}
C {dac_bridge1.sym} 970 -810 0 0 {name=A13
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {devices/lab_pin.sym} 1200 -830 2 0 {name=p19 sig_type=std_logic lab=B0}
C {dac_bridge1.sym} 970 -790 0 0 {name=A14
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {devices/lab_pin.sym} 1200 -810 2 0 {name=p20 sig_type=std_logic lab=BN7}
C {dac_bridge1.sym} 970 -770 0 0 {name=A15
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {devices/lab_pin.sym} 1200 -790 2 0 {name=p21 sig_type=std_logic lab=BN6}
C {dac_bridge1.sym} 970 -750 0 0 {name=A16
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {devices/lab_pin.sym} 1200 -770 2 0 {name=p22 sig_type=std_logic lab=BN5}
C {dac_bridge1.sym} 970 -730 0 0 {name=A17
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {devices/lab_pin.sym} 1200 -750 2 0 {name=p23 sig_type=std_logic lab=BN4}
C {dac_bridge1.sym} 970 -710 0 0 {name=A18
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {devices/lab_pin.sym} 1200 -730 2 0 {name=p24 sig_type=std_logic lab=BN3}
C {dac_bridge1.sym} 970 -690 0 0 {name=A19
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {devices/lab_pin.sym} 1200 -710 2 0 {name=p25 sig_type=std_logic lab=BN2}
C {dac_bridge1.sym} 970 -670 0 0 {name=A20
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {devices/lab_pin.sym} 1200 -690 2 0 {name=p26 sig_type=std_logic lab=BN1}
C {dac_bridge1.sym} 970 -650 0 0 {name=A21
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {devices/lab_pin.sym} 1200 -670 2 0 {name=p27 sig_type=std_logic lab=BN0}
C {dac_bridge1.sym} 970 -630 0 0 {name=A22
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {devices/lab_pin.sym} 1200 -650 2 0 {name=p28 sig_type=std_logic lab=D7}
C {dac_bridge1.sym} 970 -610 0 0 {name=A23
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {devices/lab_pin.sym} 1200 -630 2 0 {name=p29 sig_type=std_logic lab=D6}
C {dac_bridge1.sym} 970 -590 0 0 {name=A24
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {devices/lab_pin.sym} 1200 -610 2 0 {name=p30 sig_type=std_logic lab=D5}
C {dac_bridge1.sym} 970 -570 0 0 {name=A25
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {devices/lab_pin.sym} 1200 -590 2 0 {name=p31 sig_type=std_logic lab=D4}
C {dac_bridge1.sym} 970 -550 0 0 {name=A26
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {devices/lab_pin.sym} 1200 -570 2 0 {name=p32 sig_type=std_logic lab=D3}
C {dac_bridge1.sym} 970 -530 0 0 {name=A27
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {devices/lab_pin.sym} 1200 -550 2 0 {name=p33 sig_type=std_logic lab=D2}
C {dac_bridge1.sym} 970 -510 0 0 {name=A28
dac=dac1
dac_bridge_model=dac_bridge
in_low=0.0
in_high=1.2
}
C {devices/lab_pin.sym} 1200 -530 2 0 {name=p34 sig_type=std_logic lab=D1}
C {devices/lab_pin.sym} 1200 -510 2 0 {name=p35 sig_type=std_logic lab=D0}
C {devices/gnd.sym} 340 -640 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} 340 -720 2 0 {name=p1 sig_type=std_logic lab=clk}
C {devices/vsource.sym} 340 -680 0 0 {name=V4 value="dc 0 ac 0 PULSE(0 1.2 0 10p 10p 5u 10u)"}
