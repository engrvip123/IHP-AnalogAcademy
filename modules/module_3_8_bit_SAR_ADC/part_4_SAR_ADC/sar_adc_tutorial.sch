v {xschem version=3.4.6 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
B 2 1865 -530 2665 -130 {flags=graph
y1=1.5686
y2=2.9116
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.2163123e-06
x2=2.9438885e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color="12 7"
node="cdac_v+
cdac_v-"
hilight_wave=0
hcursor1_y=1.2502139}
B 2 1865 -940 2665 -540 {flags=graph
y1=0
y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.2163123e-06
x2=2.9438885e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
hcursor1_y=1.0065781
color=11
node=dac_clk}
B 2 2675 -940 3475 -540 {flags=graph
y1=-0.0047
y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.2163123e-06
x2=2.9438885e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color=7
node=clk_algo
}
B 2 2675 -530 3475 -130 {flags=graph
y1=-0.0047
y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.2163123e-06
x2=2.9438885e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color=11
node=clk_samp}
B 2 3485 -940 4285 -540 {flags=graph
y1=-0.0047
y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.2163123e-06
x2=2.9438885e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color=10
node=clk_comp
}
B 2 3485 -530 4285 -130 {flags=graph
y1=0
y2=1.3
ypos1=0
ypos2=2
divy=5
subdivy=1
unity=1
x1=2.2163123e-06
x2=2.9438885e-06
divx=5
subdivx=1
xlabmag=1.0
ylabmag=1.0
dataset=-1
unitx=1
logx=0
logy=0
color=11
node=dac_clk}
N -95 -590 -35 -590 {
lab=#net1}
N -175 -590 -155 -590 {lab=clk_samp}
N -175 -610 -155 -610 {lab=Om}
N -175 -630 -155 -630 {lab=vdd}
N -175 -650 -155 -650 {lab=Op}
N 125 -840 175 -840 {lab=#net2}
N 125 -820 175 -820 {lab=#net3}
N 125 -800 175 -800 {lab=#net4}
N 125 -780 175 -780 {lab=#net5}
N 125 -760 175 -760 {lab=#net6}
N 125 -740 175 -740 {lab=#net7}
N 125 -720 175 -720 {lab=#net8}
N 125 -700 175 -700 {lab=#net9}
N 125 -680 175 -680 {lab=#net10}
N 125 -660 175 -660 {lab=#net11}
N 125 -640 175 -640 {lab=#net12}
N 125 -620 175 -620 {lab=#net13}
N 125 -600 175 -600 {lab=#net14}
N 125 -580 175 -580 {lab=#net15}
N 125 -560 175 -560 {lab=#net16}
N 125 -540 175 -540 {lab=#net17}
N 125 -520 175 -520 {lab=#net18}
N 125 -500 175 -500 {lab=#net19}
N 125 -480 175 -480 {lab=#net20}
N 125 -460 175 -460 {lab=#net21}
N 125 -440 175 -440 {lab=#net22}
N 125 -420 175 -420 {lab=#net23}
N 1450 -1060 1500 -1060 {lab=bias}
N 1580 -960 1580 -920 {lab=GND}
N 1210 -1360 1250 -1360 {lab=vdd}
N 1190 -1380 1190 -1360 {lab=GND}
N 1190 -1380 1310 -1380 {lab=GND}
N 980 -760 980 -740 {lab=BN_MSB}
N 1020 -760 1020 -740 {lab=BN6}
N 1050 -760 1050 -740 {lab=BN5}
N 1080 -760 1080 -740 {lab=BN4}
N 1110 -760 1110 -740 {lab=BN3}
N 1140 -760 1140 -740 {lab=BN2}
N 1170 -760 1170 -740 {lab=BN1}
N 1210 -760 1250 -760 {lab=vdd}
N 1190 -760 1190 -740 {lab=GND}
N 1190 -740 1310 -740 {lab=GND}
N 980 -1390 980 -1360 {lab=B_MSB}
N 1020 -1390 1020 -1360 {lab=B6}
N 1050 -1390 1050 -1360 {lab=B5}
N 1080 -1390 1080 -1360 {lab=B4}
N 1110 -1390 1110 -1360 {lab=B3}
N 1140 -1390 1140 -1360 {lab=B2}
N 1170 -1390 1170 -1360 {lab=B1}
N 800 -1000 920 -1000 {lab=#net24}
N 660 -1050 660 -1040 {lab=GND}
N 660 -930 660 -920 {lab=GND}
N 720 -1050 720 -1030 {lab=vdd}
N 720 -930 720 -910 {lab=vdd}
N 780 -1050 780 -1030 {lab=clk_samp}
N 580 -1120 630 -1120 {lab=vin_pos}
N 580 -1000 630 -1000 {lab=vin_neg}
N 1580 -1200 1580 -1160 {lab=vdd}
N 90 -1270 90 -1250 {lab=clk_comp}
N 90 -1210 90 -1180 {lab=GND}
N 50 -1270 50 -1250 {lab=vdd}
N 50 -1190 50 -1180 {lab=GND}
N 1630 -980 1630 -950 {lab=clk_comp}
N 50 -1400 50 -1380 {lab=bias}
N 50 -1320 50 -1310 {lab=GND}
N 780 -930 780 -910 {lab=clk_samp}
N 1780 -1070 1830 -1070 {lab=Op}
N 1780 -1050 1830 -1050 {lab=Om}
N 800 -1120 920 -1120 {lab=#net25}
N 1180 -1220 1180 -1180 {lab=vdd}
N 1180 -1220 1250 -1220 {lab=vdd}
N 1180 -1240 1180 -1220 {lab=vdd}
N 1250 -1360 1250 -1220 {lab=vdd}
N 1150 -1240 1150 -1180 {lab=#net26}
N 1120 -1240 1120 -1180 {lab=#net27}
N 1090 -1240 1090 -1180 {lab=#net28}
N 1060 -1240 1060 -1180 {lab=#net29}
N 1030 -1240 1030 -1180 {lab=#net30}
N 1000 -1240 1000 -1180 {lab=#net31}
N 970 -1240 970 -1180 {lab=#net32}
N 970 -940 970 -880 {lab=#net33}
N 1000 -940 1000 -880 {lab=#net34}
N 1030 -940 1030 -880 {lab=#net35}
N 1060 -940 1060 -880 {lab=#net36}
N 1090 -940 1090 -880 {lab=#net37}
N 1120 -940 1120 -880 {lab=#net38}
N 1150 -940 1150 -880 {lab=#net39}
N 1180 -910 1180 -880 {lab=vdd}
N 1180 -910 1250 -910 {lab=vdd}
N 1180 -940 1180 -910 {lab=vdd}
N 1250 -910 1250 -760 {lab=vdd}
N 1240 -1120 1500 -1120 {lab=CDAC_v+}
N 1240 -1000 1500 -1000 {lab=CDAC_v-}
N 90 -1400 90 -1380 {lab=clk_samp}
N 90 -1340 90 -1310 {lab=GND}
N 90 -1140 90 -1120 {lab=dac_clk}
N 90 -1080 90 -1050 {lab=GND}
N 50 -1015 50 -985 {lab=vin_pos}
N 50 -925 50 -915 {lab=GND}
N 50 -1060 50 -1050 {lab=GND}
N 50 -1140 50 -1120 {lab=vin_neg}
N -180 -670 -155 -670 {lab=clk_algo}
N -95 -670 -35 -670 {lab=#net40}
N -95 -650 -35 -650 {lab=#net41}
N -95 -630 -35 -630 {lab=#net42}
N -95 -610 -35 -610 {
lab=#net43}
N 235 -840 565 -840 {
lab=B1}
N 235 -820 565 -820 {lab=B2}
N 235 -800 565 -800 {lab=B3}
N 235 -780 565 -780 {lab=B4}
N 235 -760 565 -760 {lab=B5}
N 235 -740 565 -740 {lab=B6}
N 235 -720 565 -720 {lab=B_MSB}
N 235 -700 565 -700 {lab=BN1}
N 235 -680 565 -680 {lab=BN2}
N 235 -660 565 -660 {lab=BN3}
N 235 -640 565 -640 {lab=BN4}
N 235 -620 565 -620 {lab=BN5}
N 235 -600 565 -600 {lab=BN6}
N 235 -580 565 -580 {lab=BN_MSB}
N 235 -560 565 -560 {lab=D7}
N 235 -540 565 -540 {lab=D6}
N 235 -520 565 -520 {lab=D5}
N 235 -500 565 -500 {lab=D4}
N 235 -480 565 -480 {lab=D3}
N 235 -460 565 -460 {lab=D2}
N 235 -440 565 -440 {lab=D1}
N 235 -420 565 -420 {lab=D0}
N 480 -1500 500 -1500 {lab=Op}
N 480 -1440 500 -1440 {lab=Om}
N 590 -1580 590 -1550 {lab=vdd}
N 590 -1390 590 -1370 {lab=GND}
N 740 -1470 750 -1470 {lab=clk_algo}
N 740 -1470 740 -1450 {lab=clk_algo}
N 730 -1470 740 -1470 {lab=clk_algo}
N 740 -1390 740 -1370 {lab=GND}
N 590 -1370 740 -1370 {lab=GND}
C {devices/code_shown.sym} 1415 -690 0 0 {name=NGSPICE only_toplevel=true 
value="
.param temp=27
.param T = 1u
.param T_half = T/2
.param T_algo = T/16
.param T_algo_delay = T/10
.param T_algo_PW = T/32
.param DAC_delay = 0.99*T
.param DAC_PW = T/20
.param comparator_delay = 0.328*T

.control
tran 1u 8u 
let vin_diff = v(Vin_pos) - v(Vin_neg)
let comp_diff = v(op)- v(om)
write sar_adc_test.raw
.endc
"}
C {devices/launcher.sym} 1902.5 -70 0 0 {name=h1
descr="load waves Ctrl + left click" 
tclcommand="xschem raw_read $netlist_dir/sar_adc_test.raw tran"
}
C {devices/lab_pin.sym} 90 -1400 2 0 {name=p10 sig_type=std_logic lab=clk_samp}
C {devices/lab_pin.sym} -175 -590 2 1 {name=p2 sig_type=std_logic lab=clk_samp}
C {devices/lab_pin.sym} 1250 -1360 2 0 {name=p12 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -175 -650 2 1 {name=p3 sig_type=std_logic lab=Op}
C {devices/lab_pin.sym} -175 -630 2 1 {name=p13 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} -175 -610 2 1 {name=p14 sig_type=std_logic lab=Om}
C {devices/lab_pin.sym} 1830 -1070 2 0 {name=p36 sig_type=std_logic lab=Op}
C {devices/lab_pin.sym} 1830 -1050 2 0 {name=p37 sig_type=std_logic lab=Om}
C {devices/lab_pin.sym} 1450 -1060 2 1 {name=p5 sig_type=std_logic lab=bias}
C {gnd.sym} 1310 -1380 0 0 {name=l1 lab=GND}
C {devices/lab_pin.sym} 1250 -760 0 1 {name=p38 sig_type=std_logic lab=vdd}
C {gnd.sym} 1310 -740 2 1 {name=l2 lab=GND}
C {devices/lab_pin.sym} 980 -1390 1 0 {name=p40 sig_type=std_logic lab=B_MSB}
C {devices/lab_pin.sym} 1050 -1390 1 0 {name=p41 sig_type=std_logic lab=B5}
C {devices/lab_pin.sym} 1140 -1390 1 0 {name=p42 sig_type=std_logic lab=B2}
C {devices/lab_pin.sym} 1110 -1390 1 0 {name=p43 sig_type=std_logic lab=B3}
C {devices/lab_pin.sym} 1080 -1390 1 0 {name=p44 sig_type=std_logic lab=B4}
C {devices/lab_pin.sym} 1170 -1390 1 0 {name=p46 sig_type=std_logic lab=B1}
C {devices/lab_pin.sym} 1020 -1390 1 0 {name=p45 sig_type=std_logic lab=B6}
C {devices/lab_pin.sym} 980 -740 1 1 {name=p48 sig_type=std_logic lab=BN_MSB}
C {devices/lab_pin.sym} 1050 -740 1 1 {name=p49 sig_type=std_logic lab=BN5}
C {devices/lab_pin.sym} 1140 -740 1 1 {name=p50 sig_type=std_logic lab=BN2}
C {devices/lab_pin.sym} 1110 -740 1 1 {name=p51 sig_type=std_logic lab=BN3}
C {devices/lab_pin.sym} 1080 -740 1 1 {name=p52 sig_type=std_logic lab=BN4}
C {devices/lab_pin.sym} 1170 -740 1 1 {name=p53 sig_type=std_logic lab=BN1}
C {devices/lab_pin.sym} 1020 -740 1 1 {name=p54 sig_type=std_logic lab=BN6}
C {devices/lab_pin.sym} 565 -740 0 1 {name=p55 sig_type=std_logic lab=B6}
C {devices/lab_pin.sym} 565 -720 0 1 {name=p56 sig_type=std_logic lab=B_MSB}
C {devices/lab_pin.sym} 565 -780 0 1 {name=p57 sig_type=std_logic lab=B4}
C {devices/lab_pin.sym} 565 -840 0 1 {name=p58 sig_type=std_logic lab=B1}
C {devices/lab_pin.sym} 565 -820 0 1 {name=p59 sig_type=std_logic lab=B2}
C {devices/lab_pin.sym} 565 -800 0 1 {name=p60 sig_type=std_logic lab=B3}
C {devices/lab_pin.sym} 565 -760 0 1 {name=p62 sig_type=std_logic lab=B5}
C {devices/lab_pin.sym} 565 -580 0 1 {name=p1 sig_type=std_logic lab=BN_MSB}
C {devices/lab_pin.sym} 565 -620 0 1 {name=p6 sig_type=std_logic lab=BN5}
C {devices/lab_pin.sym} 565 -680 0 1 {name=p7 sig_type=std_logic lab=BN2}
C {devices/lab_pin.sym} 565 -660 0 1 {name=p15 sig_type=std_logic lab=BN3}
C {devices/lab_pin.sym} 565 -640 0 1 {name=p16 sig_type=std_logic lab=BN4}
C {devices/lab_pin.sym} 565 -700 0 1 {name=p18 sig_type=std_logic lab=BN1}
C {devices/lab_pin.sym} 565 -600 0 1 {name=p19 sig_type=std_logic lab=BN6}
C {gnd.sym} 660 -1040 0 1 {name=l3 lab=GND}
C {gnd.sym} 660 -920 0 1 {name=l4 lab=GND}
C {devices/lab_pin.sym} 720 -1030 2 0 {name=p20 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 90 -1270 2 0 {name=p24 sig_type=std_logic lab=clk_comp}
C {devices/gnd.sym} 90 -1180 0 0 {name=l6 lab=GND}
C {devices/vsource.sym} 90 -1220 0 0 {name=V1 value="dc 0 ac 0 PULSE(0 1.2 comparator_delay 10p 10p T_algo_PW T_algo)"}
C {devices/vsource.sym} 50 -1220 0 1 {name=V6 value=1.2}
C {devices/gnd.sym} 50 -1180 0 1 {name=l11 lab=GND
value=1.2}
C {devices/lab_pin.sym} 50 -1270 2 1 {name=p26 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 1580 -1200 2 0 {name=p65 sig_type=std_logic lab=vdd}
C {gnd.sym} 1580 -920 0 1 {name=l12 lab=GND}
C {devices/lab_pin.sym} 1630 -950 2 0 {name=p66 sig_type=std_logic lab=clk_comp}
C {iopin.sym} 565 -540 0 0 {name=p67 lab=D6}
C {iopin.sym} 565 -520 0 0 {name=p28 lab=D5}
C {iopin.sym} 565 -500 0 0 {name=p29 lab=D4}
C {iopin.sym} 565 -480 0 0 {name=p30 lab=D3}
C {iopin.sym} 565 -460 0 0 {name=p31 lab=D2}
C {iopin.sym} 565 -440 0 0 {name=p32 lab=D1}
C {iopin.sym} 565 -420 0 0 {name=p33 lab=D0}
C {devices/code_shown.sym} -95 -1525 0 0 {name=MODEL only_toplevel=true
format="tcleval( @value )"
value=".lib cornerMOSlv.lib mos_tt
.lib $::SG13G2_MODELS/cornerCAP.lib cap_typ
"}
C {devices/vsource.sym} 50 -1350 0 1 {name=V7 value=0.6}
C {devices/gnd.sym} 50 -1310 0 1 {name=l13 lab=GND
value=1.2}
C {devices/lab_pin.sym} 50 -1400 2 1 {name=p68 sig_type=std_logic lab=bias}
C {devices/lab_pin.sym} 780 -1030 2 0 {name=p22 sig_type=std_logic lab=clk_samp}
C {devices/lab_pin.sym} 720 -910 2 0 {name=p21 sig_type=std_logic lab=vdd}
C {devices/lab_pin.sym} 780 -910 2 0 {name=p23 sig_type=std_logic lab=clk_samp}
C {devices/lab_pin.sym} 1280 -1120 3 1 {name=p74 sig_type=std_logic lab=CDAC_v+}
C {devices/lab_pin.sym} 1280 -1000 1 1 {name=p73 sig_type=std_logic lab=CDAC_v-}
C {devices/lab_pin.sym} 580 -1120 2 1 {name=p25 sig_type=std_logic lab=vin_pos}
C {devices/lab_pin.sym} 580 -1000 2 1 {name=p69 sig_type=std_logic lab=vin_neg}
C {devices/lab_pin.sym} 50 -1015 2 1 {name=p75 sig_type=std_logic lab=vin_pos}
C {iopin.sym} 565 -560 0 0 {name=p4 lab=D7}
C {devices/gnd.sym} 90 -1310 0 0 {name=l9 lab=GND}
C {devices/gnd.sym} 90 -1050 0 0 {name=l18 lab=GND}
C {devices/vsource.sym} 90 -1090 0 0 {name=V12 value="dc 0 ac 0 PULSE(0 1.2 DAC_delay 10p 10p DAC_PW T)"}
C {iopin.sym} 90 -1140 0 0 {name=p17 lab=dac_clk
}
C {devices/gnd.sym} 50 -915 0 1 {name=l19 lab=GND}
C {devices/gnd.sym} 50 -1050 0 1 {name=l20 lab=GND}
C {devices/vsource.sym} 50 -955 0 1 {name=V11 value=0.8}
C {devices/vsource.sym} 50 -1090 0 1 {name=V4 value=0.4}
C {devices/lab_pin.sym} -180 -670 2 1 {name=p27 sig_type=std_logic lab=clk_algo}
C {devices/lab_pin.sym} 50 -1140 2 1 {name=p8 sig_type=std_logic lab=vin_neg}
C {devices/vsource.sym} 90 -1350 0 0 {name=V5 value="dc 0 ac 0 PULSE(0 1.2 0 10p 10p T_half T)"}
C {devices/lab_pin.sym} 480 -1500 2 1 {name=p9 sig_type=std_logic lab=Op}
C {devices/lab_pin.sym} 480 -1440 2 1 {name=p11 sig_type=std_logic lab=Om}
C {devices/lab_pin.sym} 590 -1580 2 1 {name=p34 sig_type=std_logic lab=vdd}
C {devices/gnd.sym} 590 -1370 0 1 {name=l7 lab=GND
value=1.2}
C {capa.sym} 740 -1420 0 0 {name=C3
m=1
value=20f
footprint=1206
device="ceramic capacitor"}
C {devices/lab_pin.sym} 750 -1470 2 0 {name=p35 sig_type=std_logic lab=clk_algo}
C {sar_logic.sym} 45 -630 0 0 {name=adut
dut=dut
d_cosim_model= d_cosim
model=./sar_logic.so}
C {adc_bridge1.sym} -125 -670 0 0 {name=A6
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.2
in_high=0.8
}
C {adc_bridge1.sym} -125 -650 0 0 {name=A1
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.2
in_high=0.8
}
C {adc_bridge1.sym} -125 -630 0 0 {name=A2
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.2
in_high=0.8
}
C {adc_bridge1.sym} -125 -610 0 0 {name=A3
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.2
in_high=0.8
}
C {adc_bridge1.sym} -125 -590 0 0 {name=A4
adc=adc1
adc_bridge_model=adc_bridge
in_low=0.2
in_high=0.8
}
C {dac_bridge1.sym} 205 -840 0 0 {name=A5
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -820 0 0 {name=A7
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -800 0 0 {name=A8
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -780 0 0 {name=A9
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -760 0 0 {name=A10
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -740 0 0 {name=A11
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -720 0 0 {name=A12
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -700 0 0 {name=A13
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -680 0 0 {name=A14
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -660 0 0 {name=A15
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -640 0 0 {name=A16
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -620 0 0 {name=A17
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -600 0 0 {name=A18
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -580 0 0 {name=A19
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -560 0 0 {name=A20
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -540 0 0 {name=A21
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -520 0 0 {name=A22
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -500 0 0 {name=A23
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -480 0 0 {name=A24
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -460 0 0 {name=A25
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -440 0 0 {name=A26
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {dac_bridge1.sym} 205 -420 0 0 {name=A27
dac=dac1
dac_bridge_model=dac_bridge
out_low=0
out_high=1.2
}
C {switch_array.sym} 1080 -1300 2 1 {name=x4}
C {C-DAC.sym} 1070 -1000 0 0 {name=x2}
C {C-DAC.sym} 1070 -1120 2 1 {name=x3}
C {switch_array.sym} 1080 -820 0 0 {name=x5}
C {bootstrap_switch.sym} 700 -1120 0 0 {name=x6}
C {bootstrap_switch.sym} 700 -1000 0 0 {name=x7}
C {nand_gate.sym} 650 -1460 0 0 {name=x1}
C {dynamic_comparator.sym} 1650 -1060 0 0 {name=x8}
